EXTRA_OECONF += " --enable-certgen --enable-opensslall --enable-opensslextra"
CPPFLAGS += " -DWOLFSSL_SIGNER_DER_CERT"
