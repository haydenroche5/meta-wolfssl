EXTRA_OECONF += " --enable-opensslextra --enable-opensslall --enable-certgen"
CPPFLAGS += " -DWOLFSSL_SIGNER_DER_CERT"
