EXTRA_OECONF += " --enable-keygen --enable-rsapss --enable-aesccm --enable-aesctr --enable-des3"
CPPFLAGS += " -DWOLFSSL_PUBLIC_MP"
