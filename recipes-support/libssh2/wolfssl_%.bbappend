EXTRA_OECONF += " --enable-keygen --enable-des3 --enable-dsa --enable-aesctr --enable-opensslextra"
