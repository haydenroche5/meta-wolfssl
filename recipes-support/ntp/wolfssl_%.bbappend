EXTRA_OECONF += " --enable-certgen --enable-dsa --enable-cmac --enable-opensslextra --enable-opensslall --enable-keygen"
