EXTRA_OECONF += " --enable-openssh --enable-dsa"
